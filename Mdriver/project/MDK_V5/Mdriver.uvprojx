# Keil uVision project Mdriver.uvprojx, settings and files
target Mdriver (6240000::V6.24::ARMCLANG)
  device: -AT32F435CGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mdriver +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F435CGT7, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_LOOPUNROLL, __FPU_PRESENT=1U
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\User\App;..\User\Mid;..\User\Bsp;../../libraries/cmsis/dsp/include;../../libraries/cmsis/dsp/PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_spi.c wk_tmr.c wk_usart.c wk_dma.c wk_gpio.c wk_adc.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_misc.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group Bsp
    ../User/Bsp/: bsp_adc.c bsp_tim.c bsp_spi.c
  group Mid
    ../User/Mid/: pid.c foc_math.c foc_sensor.c foc_encoder.c svpwm.c spmsm.c
  group App
    ../User/App/: foc_app.c
  group cmsis_dsp
    ../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/cmsis/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/cmsis/dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
